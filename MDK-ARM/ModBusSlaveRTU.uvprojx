# Keil uVision project ModBusSlaveRTU.uvprojx, settings and files
target ModBusSlaveRTU (6180000::V6.18::ARMCLANG)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ModBusSlaveRTU +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\MiddleWare\FreeRTOS\portable\GCC\ARM_CM4F;..\MiddleWare\FreeRTOS\include;..\Libs\HeartBeat\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ModBusSlaveRTU\ModBusSlaveRTU.sct
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32f4xx_it.c kernel.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group RTOS
    ../MiddleWare/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../MiddleWare/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ../MiddleWare/FreeRTOS/portable/MemMang/: heap_1.c
  group HeartBeat
    ../Libs/HeartBeat/Src/: led.c
software components: CMSIS:CORE 5.6.0
